# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\FWLIB\inc;..\USER;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\LED;..\HARDWARE\EC11;..\HARDWARE\POWER;..\HARDWARE\STEPPER;..\HARDWARE\MOTOR;..\HARDWARE\NRF24L01;..\HARDWARE\USART1;..\HARDWARE\TIMER;..\HARDWARE\MULTIMENU;..\HARDWARE\EXTI;..\HARDWARE\USART3;..\HARDWARE\encode;..\HARDWARE\LIMIT;..\HARDWARE\UART4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group README
    ../: readme.txt
  group HARDWARE
    ../HARDWARE/beep/: beep.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/oled/: oled.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/EC11/: ec11.c
    ../HARDWARE/POWER/: power.c
    ../HARDWARE/STEPPER/: stepper.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/NRF24L01/: 24l01.c spi.c
    ../HARDWARE/USART1/: usart1.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MULTIMENU/: multimenu.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/USART3/: UART3.c
    ../HARDWARE/encode/: encode.c
    ../HARDWARE/LIMIT/: limit.c limit.h
    ../HARDWARE/UART4/: UART4.h UART4.c
